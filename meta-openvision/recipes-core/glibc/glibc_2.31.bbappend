SRC_URI_remove = "file://0014-__ieee754_sqrt-f-are-now-inline-functions-and-call-o.patch"
