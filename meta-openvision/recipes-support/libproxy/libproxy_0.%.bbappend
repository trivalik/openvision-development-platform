SRC_URI_remove_sh4 += "file://CVE-2020-25219.patch"
