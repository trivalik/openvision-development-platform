SRC_URI = "git://github.com/OpenVisionE2/shared-mime-info.git"
