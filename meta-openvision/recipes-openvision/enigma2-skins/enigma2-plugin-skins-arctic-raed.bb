SKINNAME = "Arctic"

require raed-skins.inc
require skin-python.inc
