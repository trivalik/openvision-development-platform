# Make sure it starts before udev

INITSCRIPT_PARAMS = "start 03 S ."
