PACKAGES =+ " dvbfetool"

FILES_dvbfetool = "${bindir}/dvb-fe-tool"
